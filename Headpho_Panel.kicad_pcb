File: Headpho_Panel.kicad_pcb (KiCad board)
At the start: 2 copper layers, 20 x 128.5 mm, 8 parts

Commit message: v1.1 ready for final check
Parts:
- turned REF** to 90 degrees
